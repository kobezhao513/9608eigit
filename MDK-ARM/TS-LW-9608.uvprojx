# Keil uVision project TS-LW-9608.uvprojx, settings and files
target TS-LW-9608 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F071CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TS-LW-9608 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;..\DeviceSupport;..\Libraries\CMSIS\Device\ST\STM32F0xx\Source;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\APP\flash;..\APP\main;..\APP\Parallel_Port;..\APP\RS232_485;..\APP\sys_init;..\APP\Timer;..\APP\Controller;..\APP\Record;..\APP\synch;..\APP\bus;..\APP\basic;..\APP\RTC;..\APP\led;..\APP\EI;..\FAT-FS\src;..\FAT-FS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x200000c0 size 0x3f40
  group Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Main
    ../APP/main/: main.c
  group Sys_init
    ../APP/Timer/: Timer.c
    ../APP/sys_init/: Sys_init.c
    ../APP/basic/: basic.c
    ../APP/RTC/: rtc.c
    ../APP/led/: led.c
    ../FAT-FS/src/: ffunicode.c
    ../APP/bus/: uart.c bus_basic_cmd.c
  group CMSIS
    ../DeviceSupport/: system_stm32f0xx.c
  group MDK_ARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Parallel_APP
    ../APP/Parallel_Port/: Parallel_Port.c
  group RS232_485
    ../APP/RS232_485/: rs232_485.c
  group Controller_APP
    ../APP/Controller/: Controller.c
    ../APP/synch/: pc_comm.c
  group Flash_APP
    ../APP/Record/: record_manage.c record_status.c
    ../APP/flash/: ex_flash.c
  group Controller IF
    ../APP/Controller/: TS.c
  group EI_Print
    ../APP/EI/: EI_Print_COMM.c
software components: CMSIS:CORE 5.0.1
